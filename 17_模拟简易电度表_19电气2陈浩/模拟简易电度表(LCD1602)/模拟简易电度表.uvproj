# Keil uVision project 模拟简易电度表.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 模拟简易电度表 +hex
  c flags: Optimize=8 SizeSpeed=1
  group SourceFiles
    ./: main.c TLC549.c DS1302.c key.c I2C.c EEPROM.c T0T1.c display.c LCD1602.c
  group IncludeFiles
    ./: DS1302.h TLC549.h key.h I2C.h EEPROM.h T0T1.h display.h LCD1602.h main.h
